# Just a comment line to avoid PAK archive (application/x-pak)
PACKAGECONFIG = "openssl"

CFLAGS_append_sh4 = " -std=gnu11"
