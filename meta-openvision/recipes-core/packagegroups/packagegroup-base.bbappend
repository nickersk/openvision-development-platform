RDEPENDS_packagegroup-base-bluetooth = "\
	bluez5 \
	"

RDEPENDS_packagegroup-base += "\
	stb-hwclock \
	fake-hwclock \
	"
