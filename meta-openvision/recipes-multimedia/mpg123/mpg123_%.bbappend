RDEPENDS_${PN} = "libltdl"

inherit upx_compress
