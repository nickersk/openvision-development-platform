FILES_dvbfetool = "${bindir}/dvb-fe-tool"

PACKAGES =+ " dvbfetool"
