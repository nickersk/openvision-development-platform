SRC_URI_remove = "git://git.xiph.org/tremor.git;protocol=https"
SRC_URI_append = " git://github.com/OpenVisionE2/tremor.git;protocol=https"
