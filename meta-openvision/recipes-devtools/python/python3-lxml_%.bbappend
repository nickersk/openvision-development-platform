RDEPENDS_${PN} += "python3-cssselect"

include python-package-split.inc
