DEPENDS += "python3-setuptools-native"
include python-package-split.inc
