SRC_URI = "git://github.com/freedesktop/xdg-shared-mime-info.git"
