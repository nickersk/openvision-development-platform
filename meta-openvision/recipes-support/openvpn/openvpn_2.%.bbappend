inherit upx_compress

RDEPENDS_${PN} += "kernel-module-tun"
